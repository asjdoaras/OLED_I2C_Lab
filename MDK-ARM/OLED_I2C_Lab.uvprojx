# Keil uVision project OLED_I2C_Lab.uvprojx, settings and files
target OLED_I2C_Lab (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OLED_I2C_Lab +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;.\Application\User\Core;..\u8g2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --remove
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ./: oled.c oled.h
  group U8G2
    ../u8g2/: u8g2_buffer.c u8g2_d_setup.c u8g2_d_memory.c u8g2_setup.c u8g2_font.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_circle.c u8g2_cleardisplay.c u8g2_hvline.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_polygon.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_display.c u8x8_gpio.c u8x8_setup.c u8x8_string.c u8x8_u16toa.c u8x8_u8toa.c u8x8_d_ssd1306_128x64_noname.c u8g2_port.c user_fonts.c u8x8_capture.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
